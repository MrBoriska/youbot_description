Commit message: Updated

File: urdf/youbot.urdf (robot description, URDF)
Before this commit: robot youbot, 22 links, 21 joints
Links:
- removed link base_laser_front_link
- removed link pen
Joints:
- removed joint base_laser_front_hokuyo_urg04_laser_joint
- removed joint pen_joint
